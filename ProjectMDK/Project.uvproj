# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\CMSIS\StartUp;..\User;..\Periph_Driver\inc;..\Periph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
  group Periph_Driver
    ../Periph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../CMSIS/StartUp/: startup_stm32f10x_md.s
